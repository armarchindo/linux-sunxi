## drivers/net/wireless/rtl8188fu/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0
config RTL8188FU
	tristate "Realtek 8188FU USB WiFi"
	depends on USB
	help
	  Help message of RTL8818FU
```
